options:
  parameters:
    author: Oleksandr Tytko
    generate_options: qt_gui
    id: rohde_schwarz_atc_modulation
    output_language: python
    title: Rohde & Schwarz ATC modulation
  states: {}

blocks:
- name: enable_voice
  id: variable_qtgui_push_button
  parameters:
    label: PTT
    pressed: '0'
    released: '1'
    type: int
    value: '1'
  states: {}
- name: high_pass_filter_cutoff
  id: variable
  parameters:
    value: '200'
  states: {}
- name: high_pass_filter_transition_width
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_feedforward_agc_cc_0_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '1028'
    reference: '0.85'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_reject_filter_0
  id: band_reject_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '2100'
    low_cutoff_freq: '2000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: enable_voice
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: float
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: high_pass_filter_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: high_pass_filter_transition_width
    win: window.WIN_HAMMING
  states: {}
- name: high_pass_filter_0_0
  id: high_pass_filter
  parameters:
    cutoff_freq: high_pass_filter_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: high_pass_filter_transition_width
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '3500'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate * 25
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_2_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3500'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '-10'
    freq0: 433.5e6
    gain0: '-10'
    if_gain0: '-10'
    sample_rate: samp_rate*25
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*25
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '25'
    taps: '[1]'
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: agc_processed
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: agc_processed
  states: {}

connections:
- [analog_feedforward_agc_cc_0_0, '0', blocks_complex_to_float_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [audio_source_0, '0', blocks_selector_1, '0']
- [band_reject_filter_0, '0', low_pass_filter_2_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_float_0_0, '0', virtual_sink_0, '0']
- [blocks_float_to_complex_0_0, '0', analog_feedforward_agc_cc_0_0, '0']
- [blocks_float_to_complex_1, '0', osmosdr_sink_0, '0']
- [blocks_float_to_complex_1, '0', qtgui_freq_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_null_source_0, '0', blocks_selector_1, '1']
- [blocks_selector_1, '0', high_pass_filter_0, '0']
- [high_pass_filter_0, '0', band_reject_filter_0, '0']
- [high_pass_filter_0_0, '0', blocks_add_xx_0, '0']
- [low_pass_filter_1, '0', blocks_float_to_complex_1, '0']
- [low_pass_filter_2_0, '0', blocks_float_to_complex_0_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_1, '0']
- [virtual_source_0, '0', high_pass_filter_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
